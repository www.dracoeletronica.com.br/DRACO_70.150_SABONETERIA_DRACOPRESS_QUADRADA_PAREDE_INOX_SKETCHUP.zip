Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.150_SABONETERIA_DRACOPRESS_QUADRADA_PAREDE_INOX.IFC
Time: 2023-12-22T11:24:37
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_70.150_SABONETERIA_DRACOPRESS_QUADRADA_PAREDE_INOX
In: Default Storey
Material: AISI 304
PSet_Mass_Property - Mass Measure: 12.396; Area Measure: 0.11151 m2; Volume Measure: 0.0015495 m3
